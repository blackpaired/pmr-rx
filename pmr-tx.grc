options:
  parameters:
    author: nikan.mantashi
    generate_options: qt_gui
    id: default
    output_language: cpp
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: freq
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: '2400000'
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2400000000'
    samplerate: samp_rate
    type: fc32
    uri: pluto.local
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_nbfm_tx_0, '0', iio_pluto_sink_0, '0']
- [analog_nbfm_tx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_sig_source_x_0, '0', analog_nbfm_tx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
